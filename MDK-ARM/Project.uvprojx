# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_DISCOVERY (ARM-ADS)
  device: STM32F767IIKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F769I_DISCOVERY +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,_TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM7,_CC_ARM,_FPU_PRESENT=1,_FPU_USED=1, __FPU_USED=1
  c misc: --C99 --cpu=Cortex-M7.fp.dp
  c include: ../Inc;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/BSP/STM32F769I-Discovery;../Drivers/BSP/Components/Common;../Utilities/Log;../Utilities/Fonts;../Utilities/CPU;..\Src;..\Src\websocket;..\Src\network
  asm misc: --cpu=Cortex-M7.fp.dp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: STM32F769I_DISCOVERY\STM32F769I_DISCOVERY.sct
  link misc: --diag_suppress=L6329 --cpu=Cortex-M7.fp.dp
  group Drivers/BSP/STM32F769I-Discovery
    ../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Example/MDK-ARM
    ./: startup_stm32f769xx.s
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_sdmmc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_sram.c stm32f7xx_hal_spi.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_uart.c stm32f7xx_hal_sdram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Example/User
    ../Src/: stm32f7xx_hal_msp.c main.c stm32f7xx_it.c stm32f7xx_lp_modes.c usart.c FiFOuart.c iUblox.c imain.c flash.c UsartSendMode.c iSetting.c
  group RTK
    ../Src/: ephemeris_rtk.c global.c lambda.c pntpos.c rtk.c rtkcmn.c rtkmain.c rtkpos.c spb.c TimeConvert.c Ublox.c
  group Websocket
    ../Src/websocket/: util.c websocket.c websocketLib.c
  group network
    ../Src/network/: LTE4G.c
software components: CMSIS:CORE 4.1.0
